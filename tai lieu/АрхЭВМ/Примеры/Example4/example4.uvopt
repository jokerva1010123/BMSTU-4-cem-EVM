<?xml version="1.0" encoding="UTF-8" standalone="no" ?>
<ProjectOpt xmlns:xsi="http://www.w3.org/2001/XMLSchema-instance" xsi:noNamespaceSchemaLocation="project_opt.xsd">

  <SchemaVersion>1.0</SchemaVersion>

  <Header>### uVision Project, (C) Keil Software</Header>

  <Extensions>
    <cExt>*.c</cExt>
    <aExt>*.s*; *.src; *.a*</aExt>
    <oExt>*.obj</oExt>
    <lExt>*.lib</lExt>
    <tExt>*.txt; *.h; *.inc</tExt>
    <pExt>*.plm</pExt>
    <CppX>*.cpp</CppX>
  </Extensions>

  <DaveTm>
    <dwLowDateTime>0</dwLowDateTime>
    <dwHighDateTime>0</dwHighDateTime>
  </DaveTm>

  <Target>
    <TargetName>Target 1</TargetName>
    <ToolsetNumber>0x4</ToolsetNumber>
    <ToolsetName>ARM-ADS</ToolsetName>
    <TargetOption>
      <CLKADS>12000000</CLKADS>
      <OPTTT>
        <gFlags>1</gFlags>
        <BeepAtEnd>1</BeepAtEnd>
        <RunSim>1</RunSim>
        <RunTarget>0</RunTarget>
      </OPTTT>
      <OPTHX>
        <HexSelection>1</HexSelection>
        <FlashByte>65535</FlashByte>
        <HexRangeLowAddress>0</HexRangeLowAddress>
        <HexRangeHighAddress>0</HexRangeHighAddress>
        <HexOffset>0</HexOffset>
      </OPTHX>
      <OPTLEX>
        <PageWidth>79</PageWidth>
        <PageLength>66</PageLength>
        <TabStop>8</TabStop>
        <ListingPath>.\</ListingPath>
      </OPTLEX>
      <Oh166RecLen>16</Oh166RecLen>
      <ListingPage>
        <CreateCListing>1</CreateCListing>
        <CreateAListing>1</CreateAListing>
        <CreateLListing>1</CreateLListing>
        <CreateIListing>0</CreateIListing>
        <AsmCond>1</AsmCond>
        <AsmSymb>1</AsmSymb>
        <AsmXref>0</AsmXref>
        <CCond>1</CCond>
        <CCode>0</CCode>
        <CListInc>0</CListInc>
        <CSymb>0</CSymb>
        <LinkerCodeListing>0</LinkerCodeListing>
      </ListingPage>
      <OPTXL>
        <LMap>1</LMap>
        <LComments>1</LComments>
        <LGenerateSymbols>1</LGenerateSymbols>
        <LLibSym>1</LLibSym>
        <LLines>1</LLines>
        <LLocSym>1</LLocSym>
        <LPubSym>1</LPubSym>
        <LXref>0</LXref>
        <LExpSel>0</LExpSel>
      </OPTXL>
      <OPTFL>
        <tvExp>1</tvExp>
        <tvExpOptDlg>0</tvExpOptDlg>
        <IsCurrentTarget>1</IsCurrentTarget>
      </OPTFL>
      <CpuCode>8</CpuCode>
      <Books>
        <Book>
          <Number>0</Number>
          <Title>Data Sheet</Title>
          <Path>DATASHTS\PHILIPS\LPC2478_DS.PDF</Path>
        </Book>
        <Book>
          <Number>1</Number>
          <Title>User Manual</Title>
          <Path>DATASHTS\PHILIPS\LPC2478_UM.pdf</Path>
        </Book>
      </Books>
      <DllOpt>
        <SimDllName>SARM.DLL</SimDllName>
        <SimDllArguments>-cLPC24xx</SimDllArguments>
        <SimDlgDllName>DARMP.DLL</SimDlgDllName>
        <SimDlgDllArguments>-pLPC2478</SimDlgDllArguments>
        <TargetDllName>SARM.DLL</TargetDllName>
        <TargetDllArguments></TargetDllArguments>
        <TargetDlgDllName>TARMP.DLL</TargetDlgDllName>
        <TargetDlgDllArguments>-pLPC2478</TargetDlgDllArguments>
      </DllOpt>
      <DebugOpt>
        <uSim>1</uSim>
        <uTrg>0</uTrg>
        <sLdApp>1</sLdApp>
        <sGomain>1</sGomain>
        <sRbreak>1</sRbreak>
        <sRwatch>1</sRwatch>
        <sRmem>1</sRmem>
        <sRfunc>1</sRfunc>
        <sRbox>1</sRbox>
        <tLdApp>1</tLdApp>
        <tGomain>0</tGomain>
        <tRbreak>1</tRbreak>
        <tRwatch>1</tRwatch>
        <tRmem>1</tRmem>
        <tRfunc>0</tRfunc>
        <tRbox>1</tRbox>
        <sRunDeb>0</sRunDeb>
        <sLrtime>0</sLrtime>
        <nTsel>0</nTsel>
        <sDll></sDll>
        <sDllPa></sDllPa>
        <sDlgDll></sDlgDll>
        <sDlgPa></sDlgPa>
        <sIfile></sIfile>
        <tDll></tDll>
        <tDllPa></tDllPa>
        <tDlgDll></tDlgDll>
        <tDlgPa></tDlgPa>
        <tIfile></tIfile>
        <pMon>BIN\UL2ARM.DLL</pMon>
      </DebugOpt>
      <TargetDriverDllRegistry>
        <SetRegEntry>
          <Number>0</Number>
          <Key>DLGDARM</Key>
          <Name>(135=-1,-1,-1,-1,0)(105=-1,-1,-1,-1,0)(145=-1,-1,-1,-1,0)(147=-1,-1,-1,-1,0)(150=-1,-1,-1,-1,0)(152=90,117,444,412,0)(151=98,125,350,560,0)(155=-1,-1,-1,-1,0)(177=-1,-1,-1,-1,0)(134=-1,-1,-1,-1,0)(80=-1,-1,-1,-1,0)(156=-1,-1,-1,-1,0)(100=-1,-1,-1,-1,0)(101=-1,-1,-1,-1,0)(160=-1,-1,-1,-1,0)(161=-1,-1,-1,-1,0)(162=-1,-1,-1,-1,0)(163=-1,-1,-1,-1,0)(164=-1,-1,-1,-1,0)(176=-1,-1,-1,-1,0)(178=-1,-1,-1,-1,0)(113=165,198,540,743,0)(112=-1,-1,-1,-1,0)(169=-1,-1,-1,-1,0)(170=-1,-1,-1,-1,0)(137=-1,-1,-1,-1,0)(138=-1,-1,-1,-1,0)(171=-1,-1,-1,-1,0)(117=-1,-1,-1,-1,0)(172=-1,-1,-1,-1,0)(173=-1,-1,-1,-1,0)(110=210,247,726,737,0)(111=-1,-1,-1,-1,0)(165=-1,-1,-1,-1,0)(166=-1,-1,-1,-1,0)(167=-1,-1,-1,-1,0)(168=-1,-1,-1,-1,0)(141=-1,-1,-1,-1,0)(144=-1,-1,-1,-1,0)(130=-1,-1,-1,-1,0)(131=-1,-1,-1,-1,0)(121=-1,-1,-1,-1,0)(122=-1,-1,-1,-1,0)(132=-1,-1,-1,-1,0)(115=-1,-1,-1,-1,0)(116=-1,-1,-1,-1,0)</Name>
        </SetRegEntry>
        <SetRegEntry>
          <Number>0</Number>
          <Key>ARMDBGFLAGS</Key>
          <Name>-T5F</Name>
        </SetRegEntry>
      </TargetDriverDllRegistry>
      <DebugFlag>
        <trace>0</trace>
        <periodic>1</periodic>
        <aLwin>1</aLwin>
        <aCover>0</aCover>
        <aSer1>1</aSer1>
        <aSer2>0</aSer2>
        <aPa>0</aPa>
        <viewmode>1</viewmode>
        <vrSel>0</vrSel>
        <aSym>0</aSym>
        <aTbox>0</aTbox>
        <AscS1>0</AscS1>
        <AscS2>0</AscS2>
        <AscS3>0</AscS3>
        <aSer3>0</aSer3>
        <eProf>0</eProf>
        <aLa>1</aLa>
        <aPa1>0</aPa1>
        <AscS4>0</AscS4>
        <aSer4>0</aSer4>
        <StkLoc>0</StkLoc>
        <TrcWin>0</TrcWin>
        <newCpu>0</newCpu>
        <uProt>0</uProt>
      </DebugFlag>
      <LintExecutable></LintExecutable>
      <LintConfigFile></LintConfigFile>
      <LogicAnalyzers>
        <Wi>
          <IntNumber>0</IntNumber>
          <FirstString>U0ACR</FirstString>
          <SecondString>0000800000000000000000000000E0FFFFFFEF41000000006400000000C817A8040000005530414352000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000010000000000000000000000000000000000000000000000000000000000000000000000B0040000</SecondString>
        </Wi>
        <Wi>
          <IntNumber>1</IntNumber>
          <FirstString>U0FCR</FirstString>
          <SecondString>0000000000000000000000000000000000E06F40000000006400000000C817A8040000005530464352000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000010000000000000000000000000000000000000000000000000000000000000000000000B0040000</SecondString>
        </Wi>
        <Wi>
          <IntNumber>2</IntNumber>
          <FirstString>U0FDR</FirstString>
          <SecondString>FF00000000000000000000000000E0FFFFFFEF41000000006400000000C817A8040000005530464452000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000010000000000000000000000000000000000000000000000000000000000000000000000B0040000</SecondString>
        </Wi>
        <Wi>
          <IntNumber>3</IntNumber>
          <FirstString>U0IER</FirstString>
          <SecondString>0080000000000000000000000000E0FFFFFFEF41000000006400000000C817A8040000005530494552000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000010000000000000000000000000000000000000000000000000000000000000000000000B0040000</SecondString>
        </Wi>
        <Wi>
          <IntNumber>4</IntNumber>
          <FirstString>U0IIR</FirstString>
          <SecondString>0000800000000000000000000000E0FFFFFFEF41000000006400000000C817A8040000005530494952000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000010000000000000000000000000000000000000000000000000000000000000000000000B0040000</SecondString>
        </Wi>
        <Wi>
          <IntNumber>5</IntNumber>
          <FirstString>U0LCR</FirstString>
          <SecondString>0000000000000000000000000000000000E06F40000000006400000000C817A80400000055304C4352000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000010000000000000000000000000000000000000000000000000000000000000000000000B0040000</SecondString>
        </Wi>
        <Wi>
          <IntNumber>6</IntNumber>
          <FirstString>U0LSR</FirstString>
          <SecondString>FF00000000000000000000000000000000E06F40000000006400000000C817A80400000055304C5352000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000010000000000000000000000000000000000000000000000000000000000000000000000B0040000</SecondString>
        </Wi>
        <Wi>
          <IntNumber>7</IntNumber>
          <FirstString>U0RBR</FirstString>
          <SecondString>0080000000000000000000000000000000E06F40000000006400000000C817A8040000005530524252000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000010000000000000000000000000000000000000000000000000000000000000000000000B0040000</SecondString>
        </Wi>
        <Wi>
          <IntNumber>8</IntNumber>
          <FirstString>U0SCR</FirstString>
          <SecondString>0000800000000000000000000000000000E06F40000000006400000000C817A8040000005530534352000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000010000000000000000000000000000000000000000000000000000000000000000000000B0040000</SecondString>
        </Wi>
        <Wi>
          <IntNumber>9</IntNumber>
          <FirstString>U0TER</FirstString>
          <SecondString>0000000000000000000000000000000000E06F40000000006400000000C817A8040000005530544552000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000010000000000000000000000000000000000000000000000000000000000000000000000B0040000</SecondString>
        </Wi>
        <Wi>
          <IntNumber>10</IntNumber>
          <FirstString>U0THR</FirstString>
          <SecondString>FF00000000000000000000000000000000E06F40000000006400000000C817A8040000005530544852000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000010000000000000000000000000000000000000000000000000000000000000000000000B0040000</SecondString>
        </Wi>
      </LogicAnalyzers>
    </TargetOption>
  </Target>

  <Group>
    <GroupName>Source Group 1</GroupName>
    <tvExp>1</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <File>
      <GroupNumber>1</GroupNumber>
      <FileNumber>1</FileNumber>
      <FileType>1</FileType>
      <tvExp>1</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>50</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>1</TopLine>
      <CurrentLine>12</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>.\MAIN.C</PathWithFileName>
      <FilenameWithoutPath>MAIN.C</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>1</GroupNumber>
      <FileNumber>2</FileNumber>
      <FileType>2</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>0</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>339</TopLine>
      <CurrentLine>347</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>.\LPC2400.s</PathWithFileName>
      <FilenameWithoutPath>LPC2400.s</FilenameWithoutPath>
    </File>
  </Group>

  <AlienFiles>
    <PathWithFilename>D:\temp\Keil\ARM\INC\Philips\LPC24xx.H</PathWithFilename>
    <TopLine>1</TopLine>
    <CurrentLine>1</CurrentLine>
    <Constant>0</Constant>
    <WindowPosition>
      <length>0</length>
      <flags>0</flags>
      <showCmd>0</showCmd>
      <MinPosition>
        <xPos>0</xPos>
        <yPos>0</yPos>
      </MinPosition>
      <MaxPosition>
        <xPos>0</xPos>
        <yPos>0</yPos>
      </MaxPosition>
      <NormalPosition>
        <Top>0</Top>
        <Left>0</Left>
        <Right>0</Right>
        <Bottom>0</Bottom>
      </NormalPosition>
    </WindowPosition>
  </AlienFiles>

  <AlienFiles>
    <PathWithFilename>D:\temp\Keil\ARM\RV31\INC\string.h</PathWithFilename>
    <TopLine>110</TopLine>
    <CurrentLine>132</CurrentLine>
    <Constant>0</Constant>
    <WindowPosition>
      <length>0</length>
      <flags>0</flags>
      <showCmd>0</showCmd>
      <MinPosition>
        <xPos>0</xPos>
        <yPos>0</yPos>
      </MinPosition>
      <MaxPosition>
        <xPos>0</xPos>
        <yPos>0</yPos>
      </MaxPosition>
      <NormalPosition>
        <Top>0</Top>
        <Left>0</Left>
        <Right>0</Right>
        <Bottom>0</Bottom>
      </NormalPosition>
    </WindowPosition>
  </AlienFiles>

  <WinLayout>
    <sActiveDebugView>Default</sActiveDebugView>
    <iActiveDebugViewLocation>1</iActiveDebugViewLocation>
    <sActiveBuildView>Build</sActiveBuildView>
    <iActiveBuildViewLocation>0</iActiveBuildViewLocation>
    <View>
      <ViewName>Default</ViewName>
      <ViewType>1</ViewType>
      <Window>
        <WinId>59392</WinId>
        <ItemNo>1</ItemNo>
        <Name>File</Name>
        <AnchorWinID>0</AnchorWinID>
        <AnchorWinName></AnchorWinName>
        <OtherWinID>0</OtherWinID>
        <OtherWinName></OtherWinName>
        <WinType>1</WinType>
        <DockType>2</DockType>
        <DockLocation>3</DockLocation>
        <Pinned>0</Pinned>
        <DockedRect_top>24</DockedRect_top>
        <DockedRect_left>0</DockedRect_left>
        <DockedRect_bottom>50</DockedRect_bottom>
        <DockedRect_right>893</DockedRect_right>
        <FloatingRect_top>0</FloatingRect_top>
        <FloatingRect_left>0</FloatingRect_left>
        <FloatingRect_bottom>0</FloatingRect_bottom>
        <FloatingRect_right>0</FloatingRect_right>
        <ContainerPercent>100</ContainerPercent>
        <ActiveTab>0</ActiveTab>
        <Visible>1</Visible>
        <Dynamic>0</Dynamic>
      </Window>
      <Window>
        <WinId>59398</WinId>
        <ItemNo>2</ItemNo>
        <Name>Build</Name>
        <AnchorWinID>0</AnchorWinID>
        <AnchorWinName></AnchorWinName>
        <OtherWinID>0</OtherWinID>
        <OtherWinName></OtherWinName>
        <WinType>1</WinType>
        <DockType>2</DockType>
        <DockLocation>3</DockLocation>
        <Pinned>0</Pinned>
        <DockedRect_top>50</DockedRect_top>
        <DockedRect_left>0</DockedRect_left>
        <DockedRect_bottom>76</DockedRect_bottom>
        <DockedRect_right>384</DockedRect_right>
        <FloatingRect_top>0</FloatingRect_top>
        <FloatingRect_left>0</FloatingRect_left>
        <FloatingRect_bottom>0</FloatingRect_bottom>
        <FloatingRect_right>0</FloatingRect_right>
        <ContainerPercent>100</ContainerPercent>
        <ActiveTab>0</ActiveTab>
        <Visible>0</Visible>
        <Dynamic>0</Dynamic>
      </Window>
      <Window>
        <WinId>59399</WinId>
        <ItemNo>3</ItemNo>
        <Name>Debug</Name>
        <AnchorWinID>0</AnchorWinID>
        <AnchorWinName></AnchorWinName>
        <OtherWinID>0</OtherWinID>
        <OtherWinName></OtherWinName>
        <WinType>1</WinType>
        <DockType>2</DockType>
        <DockLocation>3</DockLocation>
        <Pinned>0</Pinned>
        <DockedRect_top>50</DockedRect_top>
        <DockedRect_left>0</DockedRect_left>
        <DockedRect_bottom>76</DockedRect_bottom>
        <DockedRect_right>626</DockedRect_right>
        <FloatingRect_top>0</FloatingRect_top>
        <FloatingRect_left>0</FloatingRect_left>
        <FloatingRect_bottom>0</FloatingRect_bottom>
        <FloatingRect_right>0</FloatingRect_right>
        <ContainerPercent>100</ContainerPercent>
        <ActiveTab>0</ActiveTab>
        <Visible>1</Visible>
        <Dynamic>0</Dynamic>
      </Window>
      <Window>
        <WinId>197</WinId>
        <ItemNo>4</ItemNo>
        <Name>Build Output</Name>
        <AnchorWinID>0</AnchorWinID>
        <AnchorWinName></AnchorWinName>
        <OtherWinID>0</OtherWinID>
        <OtherWinName></OtherWinName>
        <WinType>1</WinType>
        <DockType>2</DockType>
        <DockLocation>4</DockLocation>
        <Pinned>0</Pinned>
        <DockedRect_top>749</DockedRect_top>
        <DockedRect_left>0</DockedRect_left>
        <DockedRect_bottom>959</DockedRect_bottom>
        <DockedRect_right>1400</DockedRect_right>
        <FloatingRect_top>0</FloatingRect_top>
        <FloatingRect_left>0</FloatingRect_left>
        <FloatingRect_bottom>250</FloatingRect_bottom>
        <FloatingRect_right>600</FloatingRect_right>
        <ContainerPercent>100</ContainerPercent>
        <ActiveTab>0</ActiveTab>
        <Visible>0</Visible>
        <Dynamic>0</Dynamic>
      </Window>
      <Window>
        <WinId>198</WinId>
        <ItemNo>5</ItemNo>
        <Name>Command</Name>
        <AnchorWinID>197</AnchorWinID>
        <AnchorWinName></AnchorWinName>
        <OtherWinID>0</OtherWinID>
        <OtherWinName></OtherWinName>
        <WinType>1</WinType>
        <DockType>4</DockType>
        <DockLocation>2</DockLocation>
        <Pinned>0</Pinned>
        <DockedRect_top>749</DockedRect_top>
        <DockedRect_left>0</DockedRect_left>
        <DockedRect_bottom>959</DockedRect_bottom>
        <DockedRect_right>1400</DockedRect_right>
        <FloatingRect_top>0</FloatingRect_top>
        <FloatingRect_left>0</FloatingRect_left>
        <FloatingRect_bottom>250</FloatingRect_bottom>
        <FloatingRect_right>600</FloatingRect_right>
        <ContainerPercent>100</ContainerPercent>
        <ActiveTab>0</ActiveTab>
        <Visible>1</Visible>
        <Dynamic>0</Dynamic>
      </Window>
      <Window>
        <WinId>199</WinId>
        <ItemNo>6</ItemNo>
        <Name>Find in Files</Name>
        <AnchorWinID>198</AnchorWinID>
        <AnchorWinName></AnchorWinName>
        <OtherWinID>0</OtherWinID>
        <OtherWinName></OtherWinName>
        <WinType>1</WinType>
        <DockType>4</DockType>
        <DockLocation>2</DockLocation>
        <Pinned>0</Pinned>
        <DockedRect_top>749</DockedRect_top>
        <DockedRect_left>0</DockedRect_left>
        <DockedRect_bottom>959</DockedRect_bottom>
        <DockedRect_right>1400</DockedRect_right>
        <FloatingRect_top>0</FloatingRect_top>
        <FloatingRect_left>0</FloatingRect_left>
        <FloatingRect_bottom>250</FloatingRect_bottom>
        <FloatingRect_right>600</FloatingRect_right>
        <ContainerPercent>100</ContainerPercent>
        <ActiveTab>0</ActiveTab>
        <Visible>0</Visible>
        <Dynamic>0</Dynamic>
      </Window>
      <Window>
        <WinId>38007</WinId>
        <ItemNo>7</ItemNo>
        <Name>Browse</Name>
        <AnchorWinID>199</AnchorWinID>
        <AnchorWinName></AnchorWinName>
        <OtherWinID>0</OtherWinID>
        <OtherWinName></OtherWinName>
        <WinType>1</WinType>
        <DockType>4</DockType>
        <DockLocation>2</DockLocation>
        <Pinned>0</Pinned>
        <DockedRect_top>749</DockedRect_top>
        <DockedRect_left>0</DockedRect_left>
        <DockedRect_bottom>959</DockedRect_bottom>
        <DockedRect_right>1400</DockedRect_right>
        <FloatingRect_top>0</FloatingRect_top>
        <FloatingRect_left>0</FloatingRect_left>
        <FloatingRect_bottom>250</FloatingRect_bottom>
        <FloatingRect_right>600</FloatingRect_right>
        <ContainerPercent>100</ContainerPercent>
        <ActiveTab>0</ActiveTab>
        <Visible>0</Visible>
        <Dynamic>0</Dynamic>
      </Window>
      <Window>
        <WinId>1939</WinId>
        <ItemNo>8</ItemNo>
        <Name>UART #1</Name>
        <AnchorWinID>38007</AnchorWinID>
        <AnchorWinName></AnchorWinName>
        <OtherWinID>0</OtherWinID>
        <OtherWinName></OtherWinName>
        <WinType>1</WinType>
        <DockType>4</DockType>
        <DockLocation>2</DockLocation>
        <Pinned>0</Pinned>
        <DockedRect_top>749</DockedRect_top>
        <DockedRect_left>0</DockedRect_left>
        <DockedRect_bottom>959</DockedRect_bottom>
        <DockedRect_right>1400</DockedRect_right>
        <FloatingRect_top>0</FloatingRect_top>
        <FloatingRect_left>0</FloatingRect_left>
        <FloatingRect_bottom>250</FloatingRect_bottom>
        <FloatingRect_right>600</FloatingRect_right>
        <ContainerPercent>100</ContainerPercent>
        <ActiveTab>1</ActiveTab>
        <Visible>1</Visible>
        <Dynamic>0</Dynamic>
      </Window>
      <Window>
        <WinId>1940</WinId>
        <ItemNo>9</ItemNo>
        <Name>UART #2</Name>
        <AnchorWinID>1939</AnchorWinID>
        <AnchorWinName></AnchorWinName>
        <OtherWinID>0</OtherWinID>
        <OtherWinName></OtherWinName>
        <WinType>1</WinType>
        <DockType>4</DockType>
        <DockLocation>2</DockLocation>
        <Pinned>0</Pinned>
        <DockedRect_top>749</DockedRect_top>
        <DockedRect_left>0</DockedRect_left>
        <DockedRect_bottom>959</DockedRect_bottom>
        <DockedRect_right>1400</DockedRect_right>
        <FloatingRect_top>0</FloatingRect_top>
        <FloatingRect_left>0</FloatingRect_left>
        <FloatingRect_bottom>250</FloatingRect_bottom>
        <FloatingRect_right>600</FloatingRect_right>
        <ContainerPercent>100</ContainerPercent>
        <ActiveTab>0</ActiveTab>
        <Visible>0</Visible>
        <Dynamic>0</Dynamic>
      </Window>
      <Window>
        <WinId>1941</WinId>
        <ItemNo>10</ItemNo>
        <Name>UART #3</Name>
        <AnchorWinID>1940</AnchorWinID>
        <AnchorWinName></AnchorWinName>
        <OtherWinID>0</OtherWinID>
        <OtherWinName></OtherWinName>
        <WinType>1</WinType>
        <DockType>4</DockType>
        <DockLocation>2</DockLocation>
        <Pinned>0</Pinned>
        <DockedRect_top>749</DockedRect_top>
        <DockedRect_left>0</DockedRect_left>
        <DockedRect_bottom>959</DockedRect_bottom>
        <DockedRect_right>1400</DockedRect_right>
        <FloatingRect_top>0</FloatingRect_top>
        <FloatingRect_left>0</FloatingRect_left>
        <FloatingRect_bottom>250</FloatingRect_bottom>
        <FloatingRect_right>600</FloatingRect_right>
        <ContainerPercent>100</ContainerPercent>
        <ActiveTab>0</ActiveTab>
        <Visible>0</Visible>
        <Dynamic>0</Dynamic>
      </Window>
      <Window>
        <WinId>1942</WinId>
        <ItemNo>11</ItemNo>
        <Name>UART #4</Name>
        <AnchorWinID>1941</AnchorWinID>
        <AnchorWinName></AnchorWinName>
        <OtherWinID>0</OtherWinID>
        <OtherWinName></OtherWinName>
        <WinType>1</WinType>
        <DockType>4</DockType>
        <DockLocation>2</DockLocation>
        <Pinned>0</Pinned>
        <DockedRect_top>749</DockedRect_top>
        <DockedRect_left>0</DockedRect_left>
        <DockedRect_bottom>959</DockedRect_bottom>
        <DockedRect_right>1400</DockedRect_right>
        <FloatingRect_top>0</FloatingRect_top>
        <FloatingRect_left>0</FloatingRect_left>
        <FloatingRect_bottom>250</FloatingRect_bottom>
        <FloatingRect_right>600</FloatingRect_right>
        <ContainerPercent>100</ContainerPercent>
        <ActiveTab>0</ActiveTab>
        <Visible>0</Visible>
        <Dynamic>0</Dynamic>
      </Window>
      <Window>
        <WinId>1005</WinId>
        <ItemNo>12</ItemNo>
        <Name>Project</Name>
        <AnchorWinID>1942</AnchorWinID>
        <AnchorWinName></AnchorWinName>
        <OtherWinID>0</OtherWinID>
        <OtherWinName></OtherWinName>
        <WinType>1</WinType>
        <DockType>4</DockType>
        <DockLocation>2</DockLocation>
        <Pinned>0</Pinned>
        <DockedRect_top>749</DockedRect_top>
        <DockedRect_left>0</DockedRect_left>
        <DockedRect_bottom>959</DockedRect_bottom>
        <DockedRect_right>1400</DockedRect_right>
        <FloatingRect_top>0</FloatingRect_top>
        <FloatingRect_left>0</FloatingRect_left>
        <FloatingRect_bottom>250</FloatingRect_bottom>
        <FloatingRect_right>600</FloatingRect_right>
        <ContainerPercent>100</ContainerPercent>
        <ActiveTab>0</ActiveTab>
        <Visible>1</Visible>
        <Dynamic>0</Dynamic>
      </Window>
      <Window>
        <WinId>109</WinId>
        <ItemNo>13</ItemNo>
        <Name>Books</Name>
        <AnchorWinID>1005</AnchorWinID>
        <AnchorWinName></AnchorWinName>
        <OtherWinID>0</OtherWinID>
        <OtherWinName></OtherWinName>
        <WinType>1</WinType>
        <DockType>4</DockType>
        <DockLocation>2</DockLocation>
        <Pinned>0</Pinned>
        <DockedRect_top>749</DockedRect_top>
        <DockedRect_left>0</DockedRect_left>
        <DockedRect_bottom>959</DockedRect_bottom>
        <DockedRect_right>1400</DockedRect_right>
        <FloatingRect_top>0</FloatingRect_top>
        <FloatingRect_left>0</FloatingRect_left>
        <FloatingRect_bottom>250</FloatingRect_bottom>
        <FloatingRect_right>600</FloatingRect_right>
        <ContainerPercent>100</ContainerPercent>
        <ActiveTab>0</ActiveTab>
        <Visible>0</Visible>
        <Dynamic>0</Dynamic>
      </Window>
      <Window>
        <WinId>195</WinId>
        <ItemNo>14</ItemNo>
        <Name>Functions</Name>
        <AnchorWinID>109</AnchorWinID>
        <AnchorWinName></AnchorWinName>
        <OtherWinID>0</OtherWinID>
        <OtherWinName></OtherWinName>
        <WinType>1</WinType>
        <DockType>4</DockType>
        <DockLocation>2</DockLocation>
        <Pinned>0</Pinned>
        <DockedRect_top>749</DockedRect_top>
        <DockedRect_left>0</DockedRect_left>
        <DockedRect_bottom>959</DockedRect_bottom>
        <DockedRect_right>1400</DockedRect_right>
        <FloatingRect_top>0</FloatingRect_top>
        <FloatingRect_left>0</FloatingRect_left>
        <FloatingRect_bottom>250</FloatingRect_bottom>
        <FloatingRect_right>600</FloatingRect_right>
        <ContainerPercent>100</ContainerPercent>
        <ActiveTab>0</ActiveTab>
        <Visible>0</Visible>
        <Dynamic>0</Dynamic>
      </Window>
      <Window>
        <WinId>196</WinId>
        <ItemNo>15</ItemNo>
        <Name>Templates</Name>
        <AnchorWinID>195</AnchorWinID>
        <AnchorWinName></AnchorWinName>
        <OtherWinID>0</OtherWinID>
        <OtherWinName></OtherWinName>
        <WinType>1</WinType>
        <DockType>4</DockType>
        <DockLocation>2</DockLocation>
        <Pinned>0</Pinned>
        <DockedRect_top>749</DockedRect_top>
        <DockedRect_left>0</DockedRect_left>
        <DockedRect_bottom>959</DockedRect_bottom>
        <DockedRect_right>1400</DockedRect_right>
        <FloatingRect_top>0</FloatingRect_top>
        <FloatingRect_left>0</FloatingRect_left>
        <FloatingRect_bottom>250</FloatingRect_bottom>
        <FloatingRect_right>600</FloatingRect_right>
        <ContainerPercent>100</ContainerPercent>
        <ActiveTab>0</ActiveTab>
        <Visible>0</Visible>
        <Dynamic>0</Dynamic>
      </Window>
      <Window>
        <WinId>38003</WinId>
        <ItemNo>16</ItemNo>
        <Name>Registers</Name>
        <AnchorWinID>196</AnchorWinID>
        <AnchorWinName></AnchorWinName>
        <OtherWinID>0</OtherWinID>
        <OtherWinName></OtherWinName>
        <WinType>1</WinType>
        <DockType>4</DockType>
        <DockLocation>2</DockLocation>
        <Pinned>0</Pinned>
        <DockedRect_top>749</DockedRect_top>
        <DockedRect_left>0</DockedRect_left>
        <DockedRect_bottom>959</DockedRect_bottom>
        <DockedRect_right>1400</DockedRect_right>
        <FloatingRect_top>0</FloatingRect_top>
        <FloatingRect_left>0</FloatingRect_left>
        <FloatingRect_bottom>250</FloatingRect_bottom>
        <FloatingRect_right>600</FloatingRect_right>
        <ContainerPercent>100</ContainerPercent>
        <ActiveTab>0</ActiveTab>
        <Visible>1</Visible>
        <Dynamic>0</Dynamic>
      </Window>
      <Window>
        <WinId>1944</WinId>
        <ItemNo>17</ItemNo>
        <Name>Call Stack</Name>
        <AnchorWinID>38003</AnchorWinID>
        <AnchorWinName></AnchorWinName>
        <OtherWinID>0</OtherWinID>
        <OtherWinName></OtherWinName>
        <WinType>1</WinType>
        <DockType>4</DockType>
        <DockLocation>2</DockLocation>
        <Pinned>0</Pinned>
        <DockedRect_top>749</DockedRect_top>
        <DockedRect_left>0</DockedRect_left>
        <DockedRect_bottom>959</DockedRect_bottom>
        <DockedRect_right>1400</DockedRect_right>
        <FloatingRect_top>0</FloatingRect_top>
        <FloatingRect_left>0</FloatingRect_left>
        <FloatingRect_bottom>250</FloatingRect_bottom>
        <FloatingRect_right>600</FloatingRect_right>
        <ContainerPercent>100</ContainerPercent>
        <ActiveTab>0</ActiveTab>
        <Visible>0</Visible>
        <Dynamic>0</Dynamic>
      </Window>
      <Window>
        <WinId>1507</WinId>
        <ItemNo>18</ItemNo>
        <Name>Call Stack</Name>
        <AnchorWinID>1944</AnchorWinID>
        <AnchorWinName></AnchorWinName>
        <OtherWinID>0</OtherWinID>
        <OtherWinName></OtherWinName>
        <WinType>1</WinType>
        <DockType>4</DockType>
        <DockLocation>2</DockLocation>
        <Pinned>0</Pinned>
        <DockedRect_top>749</DockedRect_top>
        <DockedRect_left>0</DockedRect_left>
        <DockedRect_bottom>959</DockedRect_bottom>
        <DockedRect_right>1400</DockedRect_right>
        <FloatingRect_top>0</FloatingRect_top>
        <FloatingRect_left>0</FloatingRect_left>
        <FloatingRect_bottom>250</FloatingRect_bottom>
        <FloatingRect_right>600</FloatingRect_right>
        <ContainerPercent>100</ContainerPercent>
        <ActiveTab>0</ActiveTab>
        <Visible>1</Visible>
        <Dynamic>0</Dynamic>
      </Window>
      <Window>
        <WinId>1935</WinId>
        <ItemNo>19</ItemNo>
        <Name>Locals</Name>
        <AnchorWinID>1507</AnchorWinID>
        <AnchorWinName></AnchorWinName>
        <OtherWinID>0</OtherWinID>
        <OtherWinName></OtherWinName>
        <WinType>1</WinType>
        <DockType>4</DockType>
        <DockLocation>2</DockLocation>
        <Pinned>0</Pinned>
        <DockedRect_top>749</DockedRect_top>
        <DockedRect_left>0</DockedRect_left>
        <DockedRect_bottom>959</DockedRect_bottom>
        <DockedRect_right>1400</DockedRect_right>
        <FloatingRect_top>0</FloatingRect_top>
        <FloatingRect_left>0</FloatingRect_left>
        <FloatingRect_bottom>250</FloatingRect_bottom>
        <FloatingRect_right>600</FloatingRect_right>
        <ContainerPercent>100</ContainerPercent>
        <ActiveTab>0</ActiveTab>
        <Visible>1</Visible>
        <Dynamic>0</Dynamic>
      </Window>
      <Window>
        <WinId>1936</WinId>
        <ItemNo>20</ItemNo>
        <Name>Watch 1</Name>
        <AnchorWinID>1935</AnchorWinID>
        <AnchorWinName></AnchorWinName>
        <OtherWinID>0</OtherWinID>
        <OtherWinName></OtherWinName>
        <WinType>1</WinType>
        <DockType>4</DockType>
        <DockLocation>2</DockLocation>
        <Pinned>0</Pinned>
        <DockedRect_top>749</DockedRect_top>
        <DockedRect_left>0</DockedRect_left>
        <DockedRect_bottom>959</DockedRect_bottom>
        <DockedRect_right>1400</DockedRect_right>
        <FloatingRect_top>0</FloatingRect_top>
        <FloatingRect_left>0</FloatingRect_left>
        <FloatingRect_bottom>250</FloatingRect_bottom>
        <FloatingRect_right>600</FloatingRect_right>
        <ContainerPercent>100</ContainerPercent>
        <ActiveTab>0</ActiveTab>
        <Visible>1</Visible>
        <Dynamic>0</Dynamic>
      </Window>
      <Window>
        <WinId>1937</WinId>
        <ItemNo>21</ItemNo>
        <Name>Watch 2</Name>
        <AnchorWinID>1936</AnchorWinID>
        <AnchorWinName></AnchorWinName>
        <OtherWinID>0</OtherWinID>
        <OtherWinName></OtherWinName>
        <WinType>1</WinType>
        <DockType>4</DockType>
        <DockLocation>2</DockLocation>
        <Pinned>0</Pinned>
        <DockedRect_top>749</DockedRect_top>
        <DockedRect_left>0</DockedRect_left>
        <DockedRect_bottom>959</DockedRect_bottom>
        <DockedRect_right>1400</DockedRect_right>
        <FloatingRect_top>0</FloatingRect_top>
        <FloatingRect_left>0</FloatingRect_left>
        <FloatingRect_bottom>250</FloatingRect_bottom>
        <FloatingRect_right>600</FloatingRect_right>
        <ContainerPercent>100</ContainerPercent>
        <ActiveTab>0</ActiveTab>
        <Visible>0</Visible>
        <Dynamic>0</Dynamic>
      </Window>
      <Window>
        <WinId>1465</WinId>
        <ItemNo>22</ItemNo>
        <Name>Memory 1</Name>
        <AnchorWinID>1937</AnchorWinID>
        <AnchorWinName></AnchorWinName>
        <OtherWinID>0</OtherWinID>
        <OtherWinName></OtherWinName>
        <WinType>1</WinType>
        <DockType>4</DockType>
        <DockLocation>2</DockLocation>
        <Pinned>0</Pinned>
        <DockedRect_top>749</DockedRect_top>
        <DockedRect_left>0</DockedRect_left>
        <DockedRect_bottom>959</DockedRect_bottom>
        <DockedRect_right>1400</DockedRect_right>
        <FloatingRect_top>0</FloatingRect_top>
        <FloatingRect_left>0</FloatingRect_left>
        <FloatingRect_bottom>250</FloatingRect_bottom>
        <FloatingRect_right>600</FloatingRect_right>
        <ContainerPercent>100</ContainerPercent>
        <ActiveTab>0</ActiveTab>
        <Visible>1</Visible>
        <Dynamic>0</Dynamic>
      </Window>
      <Window>
        <WinId>1466</WinId>
        <ItemNo>23</ItemNo>
        <Name>Memory 2</Name>
        <AnchorWinID>1465</AnchorWinID>
        <AnchorWinName></AnchorWinName>
        <OtherWinID>0</OtherWinID>
        <OtherWinName></OtherWinName>
        <WinType>1</WinType>
        <DockType>4</DockType>
        <DockLocation>2</DockLocation>
        <Pinned>0</Pinned>
        <DockedRect_top>749</DockedRect_top>
        <DockedRect_left>0</DockedRect_left>
        <DockedRect_bottom>959</DockedRect_bottom>
        <DockedRect_right>1400</DockedRect_right>
        <FloatingRect_top>0</FloatingRect_top>
        <FloatingRect_left>0</FloatingRect_left>
        <FloatingRect_bottom>250</FloatingRect_bottom>
        <FloatingRect_right>600</FloatingRect_right>
        <ContainerPercent>100</ContainerPercent>
        <ActiveTab>0</ActiveTab>
        <Visible>0</Visible>
        <Dynamic>0</Dynamic>
      </Window>
      <Window>
        <WinId>1467</WinId>
        <ItemNo>24</ItemNo>
        <Name>Memory 3</Name>
        <AnchorWinID>1466</AnchorWinID>
        <AnchorWinName></AnchorWinName>
        <OtherWinID>0</OtherWinID>
        <OtherWinName></OtherWinName>
        <WinType>1</WinType>
        <DockType>4</DockType>
        <DockLocation>2</DockLocation>
        <Pinned>0</Pinned>
        <DockedRect_top>749</DockedRect_top>
        <DockedRect_left>0</DockedRect_left>
        <DockedRect_bottom>959</DockedRect_bottom>
        <DockedRect_right>1400</DockedRect_right>
        <FloatingRect_top>0</FloatingRect_top>
        <FloatingRect_left>0</FloatingRect_left>
        <FloatingRect_bottom>250</FloatingRect_bottom>
        <FloatingRect_right>600</FloatingRect_right>
        <ContainerPercent>100</ContainerPercent>
        <ActiveTab>0</ActiveTab>
        <Visible>0</Visible>
        <Dynamic>0</Dynamic>
      </Window>
      <Window>
        <WinId>1468</WinId>
        <ItemNo>25</ItemNo>
        <Name>Memory 4</Name>
        <AnchorWinID>1467</AnchorWinID>
        <AnchorWinName></AnchorWinName>
        <OtherWinID>0</OtherWinID>
        <OtherWinName></OtherWinName>
        <WinType>1</WinType>
        <DockType>4</DockType>
        <DockLocation>2</DockLocation>
        <Pinned>0</Pinned>
        <DockedRect_top>749</DockedRect_top>
        <DockedRect_left>0</DockedRect_left>
        <DockedRect_bottom>959</DockedRect_bottom>
        <DockedRect_right>1400</DockedRect_right>
        <FloatingRect_top>0</FloatingRect_top>
        <FloatingRect_left>0</FloatingRect_left>
        <FloatingRect_bottom>250</FloatingRect_bottom>
        <FloatingRect_right>600</FloatingRect_right>
        <ContainerPercent>100</ContainerPercent>
        <ActiveTab>0</ActiveTab>
        <Visible>0</Visible>
        <Dynamic>0</Dynamic>
      </Window>
      <Window>
        <WinId>1506</WinId>
        <ItemNo>26</ItemNo>
        <Name>Symbols</Name>
        <AnchorWinID>1468</AnchorWinID>
        <AnchorWinName></AnchorWinName>
        <OtherWinID>0</OtherWinID>
        <OtherWinName></OtherWinName>
        <WinType>1</WinType>
        <DockType>4</DockType>
        <DockLocation>2</DockLocation>
        <Pinned>0</Pinned>
        <DockedRect_top>749</DockedRect_top>
        <DockedRect_left>0</DockedRect_left>
        <DockedRect_bottom>959</DockedRect_bottom>
        <DockedRect_right>1400</DockedRect_right>
        <FloatingRect_top>0</FloatingRect_top>
        <FloatingRect_left>0</FloatingRect_left>
        <FloatingRect_bottom>250</FloatingRect_bottom>
        <FloatingRect_right>600</FloatingRect_right>
        <ContainerPercent>100</ContainerPercent>
        <ActiveTab>0</ActiveTab>
        <Visible>1</Visible>
        <Dynamic>0</Dynamic>
      </Window>
      <Window>
        <WinId>50001</WinId>
        <ItemNo>27</ItemNo>
        <Name>System Viewer Data 1</Name>
        <AnchorWinID>0</AnchorWinID>
        <AnchorWinName></AnchorWinName>
        <OtherWinID>0</OtherWinID>
        <OtherWinName></OtherWinName>
        <WinType>1</WinType>
        <DockType>2</DockType>
        <DockLocation>2</DockLocation>
        <Pinned>0</Pinned>
        <DockedRect_top>76</DockedRect_top>
        <DockedRect_left>1190</DockedRect_left>
        <DockedRect_bottom>745</DockedRect_bottom>
        <DockedRect_right>1400</DockedRect_right>
        <FloatingRect_top>0</FloatingRect_top>
        <FloatingRect_left>0</FloatingRect_left>
        <FloatingRect_bottom>600</FloatingRect_bottom>
        <FloatingRect_right>250</FloatingRect_right>
        <ContainerPercent>100</ContainerPercent>
        <ActiveTab>0</ActiveTab>
        <Visible>0</Visible>
        <Dynamic>0</Dynamic>
      </Window>
      <Window>
        <WinId>50002</WinId>
        <ItemNo>28</ItemNo>
        <Name>System Viewer Data 2</Name>
        <AnchorWinID>50001</AnchorWinID>
        <AnchorWinName></AnchorWinName>
        <OtherWinID>0</OtherWinID>
        <OtherWinName></OtherWinName>
        <WinType>1</WinType>
        <DockType>4</DockType>
        <DockLocation>2</DockLocation>
        <Pinned>0</Pinned>
        <DockedRect_top>76</DockedRect_top>
        <DockedRect_left>1190</DockedRect_left>
        <DockedRect_bottom>745</DockedRect_bottom>
        <DockedRect_right>1400</DockedRect_right>
        <FloatingRect_top>0</FloatingRect_top>
        <FloatingRect_left>0</FloatingRect_left>
        <FloatingRect_bottom>600</FloatingRect_bottom>
        <FloatingRect_right>250</FloatingRect_right>
        <ContainerPercent>100</ContainerPercent>
        <ActiveTab>0</ActiveTab>
        <Visible>0</Visible>
        <Dynamic>0</Dynamic>
      </Window>
      <Window>
        <WinId>50003</WinId>
        <ItemNo>29</ItemNo>
        <Name>System Viewer Data 3</Name>
        <AnchorWinID>50002</AnchorWinID>
        <AnchorWinName></AnchorWinName>
        <OtherWinID>0</OtherWinID>
        <OtherWinName></OtherWinName>
        <WinType>1</WinType>
        <DockType>4</DockType>
        <DockLocation>2</DockLocation>
        <Pinned>0</Pinned>
        <DockedRect_top>76</DockedRect_top>
        <DockedRect_left>1190</DockedRect_left>
        <DockedRect_bottom>745</DockedRect_bottom>
        <DockedRect_right>1400</DockedRect_right>
        <FloatingRect_top>0</FloatingRect_top>
        <FloatingRect_left>0</FloatingRect_left>
        <FloatingRect_bottom>600</FloatingRect_bottom>
        <FloatingRect_right>250</FloatingRect_right>
        <ContainerPercent>100</ContainerPercent>
        <ActiveTab>0</ActiveTab>
        <Visible>0</Visible>
        <Dynamic>0</Dynamic>
      </Window>
      <Window>
        <WinId>50004</WinId>
        <ItemNo>30</ItemNo>
        <Name>System Viewer Data 4</Name>
        <AnchorWinID>50003</AnchorWinID>
        <AnchorWinName></AnchorWinName>
        <OtherWinID>0</OtherWinID>
        <OtherWinName></OtherWinName>
        <WinType>1</WinType>
        <DockType>4</DockType>
        <DockLocation>2</DockLocation>
        <Pinned>0</Pinned>
        <DockedRect_top>76</DockedRect_top>
        <DockedRect_left>1190</DockedRect_left>
        <DockedRect_bottom>745</DockedRect_bottom>
        <DockedRect_right>1400</DockedRect_right>
        <FloatingRect_top>0</FloatingRect_top>
        <FloatingRect_left>0</FloatingRect_left>
        <FloatingRect_bottom>600</FloatingRect_bottom>
        <FloatingRect_right>250</FloatingRect_right>
        <ContainerPercent>100</ContainerPercent>
        <ActiveTab>0</ActiveTab>
        <Visible>0</Visible>
        <Dynamic>0</Dynamic>
      </Window>
      <Window>
        <WinId>50005</WinId>
        <ItemNo>31</ItemNo>
        <Name>System Viewer Data 5</Name>
        <AnchorWinID>50004</AnchorWinID>
        <AnchorWinName></AnchorWinName>
        <OtherWinID>0</OtherWinID>
        <OtherWinName></OtherWinName>
        <WinType>1</WinType>
        <DockType>4</DockType>
        <DockLocation>2</DockLocation>
        <Pinned>0</Pinned>
        <DockedRect_top>76</DockedRect_top>
        <DockedRect_left>1190</DockedRect_left>
        <DockedRect_bottom>745</DockedRect_bottom>
        <DockedRect_right>1400</DockedRect_right>
        <FloatingRect_top>0</FloatingRect_top>
        <FloatingRect_left>0</FloatingRect_left>
        <FloatingRect_bottom>600</FloatingRect_bottom>
        <FloatingRect_right>250</FloatingRect_right>
        <ContainerPercent>100</ContainerPercent>
        <ActiveTab>0</ActiveTab>
        <Visible>0</Visible>
        <Dynamic>0</Dynamic>
      </Window>
      <Window>
        <WinId>50006</WinId>
        <ItemNo>32</ItemNo>
        <Name>System Viewer Data 6</Name>
        <AnchorWinID>50005</AnchorWinID>
        <AnchorWinName></AnchorWinName>
        <OtherWinID>0</OtherWinID>
        <OtherWinName></OtherWinName>
        <WinType>1</WinType>
        <DockType>4</DockType>
        <DockLocation>2</DockLocation>
        <Pinned>0</Pinned>
        <DockedRect_top>76</DockedRect_top>
        <DockedRect_left>1190</DockedRect_left>
        <DockedRect_bottom>745</DockedRect_bottom>
        <DockedRect_right>1400</DockedRect_right>
        <FloatingRect_top>0</FloatingRect_top>
        <FloatingRect_left>0</FloatingRect_left>
        <FloatingRect_bottom>600</FloatingRect_bottom>
        <FloatingRect_right>250</FloatingRect_right>
        <ContainerPercent>100</ContainerPercent>
        <ActiveTab>0</ActiveTab>
        <Visible>0</Visible>
        <Dynamic>0</Dynamic>
      </Window>
      <Window>
        <WinId>50007</WinId>
        <ItemNo>33</ItemNo>
        <Name>System Viewer Data 7</Name>
        <AnchorWinID>50006</AnchorWinID>
        <AnchorWinName></AnchorWinName>
        <OtherWinID>0</OtherWinID>
        <OtherWinName></OtherWinName>
        <WinType>1</WinType>
        <DockType>4</DockType>
        <DockLocation>2</DockLocation>
        <Pinned>0</Pinned>
        <DockedRect_top>76</DockedRect_top>
        <DockedRect_left>1190</DockedRect_left>
        <DockedRect_bottom>745</DockedRect_bottom>
        <DockedRect_right>1400</DockedRect_right>
        <FloatingRect_top>0</FloatingRect_top>
        <FloatingRect_left>0</FloatingRect_left>
        <FloatingRect_bottom>600</FloatingRect_bottom>
        <FloatingRect_right>250</FloatingRect_right>
        <ContainerPercent>100</ContainerPercent>
        <ActiveTab>0</ActiveTab>
        <Visible>0</Visible>
        <Dynamic>0</Dynamic>
      </Window>
      <Window>
        <WinId>50008</WinId>
        <ItemNo>34</ItemNo>
        <Name>System Viewer Data 8</Name>
        <AnchorWinID>50007</AnchorWinID>
        <AnchorWinName></AnchorWinName>
        <OtherWinID>0</OtherWinID>
        <OtherWinName></OtherWinName>
        <WinType>1</WinType>
        <DockType>4</DockType>
        <DockLocation>2</DockLocation>
        <Pinned>0</Pinned>
        <DockedRect_top>76</DockedRect_top>
        <DockedRect_left>1190</DockedRect_left>
        <DockedRect_bottom>745</DockedRect_bottom>
        <DockedRect_right>1400</DockedRect_right>
        <FloatingRect_top>0</FloatingRect_top>
        <FloatingRect_left>0</FloatingRect_left>
        <FloatingRect_bottom>600</FloatingRect_bottom>
        <FloatingRect_right>250</FloatingRect_right>
        <ContainerPercent>100</ContainerPercent>
        <ActiveTab>0</ActiveTab>
        <Visible>0</Visible>
        <Dynamic>0</Dynamic>
      </Window>
      <Window>
        <WinId>50009</WinId>
        <ItemNo>35</ItemNo>
        <Name>System Viewer Data 9</Name>
        <AnchorWinID>50008</AnchorWinID>
        <AnchorWinName></AnchorWinName>
        <OtherWinID>0</OtherWinID>
        <OtherWinName></OtherWinName>
        <WinType>1</WinType>
        <DockType>4</DockType>
        <DockLocation>2</DockLocation>
        <Pinned>0</Pinned>
        <DockedRect_top>76</DockedRect_top>
        <DockedRect_left>1190</DockedRect_left>
        <DockedRect_bottom>745</DockedRect_bottom>
        <DockedRect_right>1400</DockedRect_right>
        <FloatingRect_top>0</FloatingRect_top>
        <FloatingRect_left>0</FloatingRect_left>
        <FloatingRect_bottom>600</FloatingRect_bottom>
        <FloatingRect_right>250</FloatingRect_right>
        <ContainerPercent>100</ContainerPercent>
        <ActiveTab>0</ActiveTab>
        <Visible>0</Visible>
        <Dynamic>0</Dynamic>
      </Window>
      <Window>
        <WinId>50010</WinId>
        <ItemNo>36</ItemNo>
        <Name>System Viewer Data 10</Name>
        <AnchorWinID>50009</AnchorWinID>
        <AnchorWinName></AnchorWinName>
        <OtherWinID>0</OtherWinID>
        <OtherWinName></OtherWinName>
        <WinType>1</WinType>
        <DockType>4</DockType>
        <DockLocation>2</DockLocation>
        <Pinned>0</Pinned>
        <DockedRect_top>76</DockedRect_top>
        <DockedRect_left>1190</DockedRect_left>
        <DockedRect_bottom>745</DockedRect_bottom>
        <DockedRect_right>1400</DockedRect_right>
        <FloatingRect_top>0</FloatingRect_top>
        <FloatingRect_left>0</FloatingRect_left>
        <FloatingRect_bottom>600</FloatingRect_bottom>
        <FloatingRect_right>250</FloatingRect_right>
        <ContainerPercent>100</ContainerPercent>
        <ActiveTab>0</ActiveTab>
        <Visible>0</Visible>
        <Dynamic>0</Dynamic>
      </Window>
      <Window>
        <WinId>203</WinId>
        <ItemNo>37</ItemNo>
        <Name>Disassembly</Name>
        <AnchorWinID>0</AnchorWinID>
        <AnchorWinName></AnchorWinName>
        <OtherWinID>0</OtherWinID>
        <OtherWinName></OtherWinName>
        <WinType>1</WinType>
        <DockType>2</DockType>
        <DockLocation>3</DockLocation>
        <Pinned>0</Pinned>
        <DockedRect_top>76</DockedRect_top>
        <DockedRect_left>0</DockedRect_left>
        <DockedRect_bottom>254</DockedRect_bottom>
        <DockedRect_right>1400</DockedRect_right>
        <FloatingRect_top>0</FloatingRect_top>
        <FloatingRect_left>0</FloatingRect_left>
        <FloatingRect_bottom>250</FloatingRect_bottom>
        <FloatingRect_right>600</FloatingRect_right>
        <ContainerPercent>100</ContainerPercent>
        <ActiveTab>1</ActiveTab>
        <Visible>1</Visible>
        <Dynamic>0</Dynamic>
      </Window>
      <Window>
        <WinId>1913</WinId>
        <ItemNo>38</ItemNo>
        <Name>Instruction Trace</Name>
        <AnchorWinID>203</AnchorWinID>
        <AnchorWinName></AnchorWinName>
        <OtherWinID>0</OtherWinID>
        <OtherWinName></OtherWinName>
        <WinType>1</WinType>
        <DockType>4</DockType>
        <DockLocation>2</DockLocation>
        <Pinned>0</Pinned>
        <DockedRect_top>76</DockedRect_top>
        <DockedRect_left>0</DockedRect_left>
        <DockedRect_bottom>254</DockedRect_bottom>
        <DockedRect_right>1400</DockedRect_right>
        <FloatingRect_top>0</FloatingRect_top>
        <FloatingRect_left>0</FloatingRect_left>
        <FloatingRect_bottom>250</FloatingRect_bottom>
        <FloatingRect_right>600</FloatingRect_right>
        <ContainerPercent>100</ContainerPercent>
        <ActiveTab>0</ActiveTab>
        <Visible>0</Visible>
        <Dynamic>0</Dynamic>
      </Window>
      <Window>
        <WinId>343</WinId>
        <ItemNo>39</ItemNo>
        <Name>Performance Analyzer</Name>
        <AnchorWinID>1913</AnchorWinID>
        <AnchorWinName></AnchorWinName>
        <OtherWinID>0</OtherWinID>
        <OtherWinName></OtherWinName>
        <WinType>1</WinType>
        <DockType>4</DockType>
        <DockLocation>2</DockLocation>
        <Pinned>0</Pinned>
        <DockedRect_top>76</DockedRect_top>
        <DockedRect_left>0</DockedRect_left>
        <DockedRect_bottom>254</DockedRect_bottom>
        <DockedRect_right>1400</DockedRect_right>
        <FloatingRect_top>0</FloatingRect_top>
        <FloatingRect_left>0</FloatingRect_left>
        <FloatingRect_bottom>250</FloatingRect_bottom>
        <FloatingRect_right>600</FloatingRect_right>
        <ContainerPercent>100</ContainerPercent>
        <ActiveTab>0</ActiveTab>
        <Visible>0</Visible>
        <Dynamic>0</Dynamic>
      </Window>
      <Window>
        <WinId>204</WinId>
        <ItemNo>40</ItemNo>
        <Name>Performance Analyzer</Name>
        <AnchorWinID>343</AnchorWinID>
        <AnchorWinName></AnchorWinName>
        <OtherWinID>0</OtherWinID>
        <OtherWinName></OtherWinName>
        <WinType>1</WinType>
        <DockType>4</DockType>
        <DockLocation>2</DockLocation>
        <Pinned>0</Pinned>
        <DockedRect_top>76</DockedRect_top>
        <DockedRect_left>0</DockedRect_left>
        <DockedRect_bottom>254</DockedRect_bottom>
        <DockedRect_right>1400</DockedRect_right>
        <FloatingRect_top>0</FloatingRect_top>
        <FloatingRect_left>0</FloatingRect_left>
        <FloatingRect_bottom>250</FloatingRect_bottom>
        <FloatingRect_right>600</FloatingRect_right>
        <ContainerPercent>100</ContainerPercent>
        <ActiveTab>0</ActiveTab>
        <Visible>0</Visible>
        <Dynamic>0</Dynamic>
      </Window>
      <Window>
        <WinId>346</WinId>
        <ItemNo>41</ItemNo>
        <Name>Code Coverage</Name>
        <AnchorWinID>204</AnchorWinID>
        <AnchorWinName></AnchorWinName>
        <OtherWinID>0</OtherWinID>
        <OtherWinName></OtherWinName>
        <WinType>1</WinType>
        <DockType>4</DockType>
        <DockLocation>2</DockLocation>
        <Pinned>0</Pinned>
        <DockedRect_top>76</DockedRect_top>
        <DockedRect_left>0</DockedRect_left>
        <DockedRect_bottom>254</DockedRect_bottom>
        <DockedRect_right>1400</DockedRect_right>
        <FloatingRect_top>0</FloatingRect_top>
        <FloatingRect_left>0</FloatingRect_left>
        <FloatingRect_bottom>250</FloatingRect_bottom>
        <FloatingRect_right>600</FloatingRect_right>
        <ContainerPercent>100</ContainerPercent>
        <ActiveTab>0</ActiveTab>
        <Visible>0</Visible>
        <Dynamic>0</Dynamic>
      </Window>
      <Window>
        <WinId>35824</WinId>
        <ItemNo>42</ItemNo>
        <Name>Logic Analyzer</Name>
        <AnchorWinID>0</AnchorWinID>
        <AnchorWinName></AnchorWinName>
        <OtherWinID>0</OtherWinID>
        <OtherWinName></OtherWinName>
        <WinType>1</WinType>
        <DockType>6</DockType>
        <DockLocation>0</DockLocation>
        <Pinned>0</Pinned>
        <DockedRect_top>0</DockedRect_top>
        <DockedRect_left>0</DockedRect_left>
        <DockedRect_bottom>0</DockedRect_bottom>
        <DockedRect_right>0</DockedRect_right>
        <FloatingRect_top>0</FloatingRect_top>
        <FloatingRect_left>0</FloatingRect_left>
        <FloatingRect_bottom>250</FloatingRect_bottom>
        <FloatingRect_right>600</FloatingRect_right>
        <ContainerPercent>1</ContainerPercent>
        <ActiveTab>0</ActiveTab>
        <Visible>1</Visible>
        <Dynamic>0</Dynamic>
      </Window>
    </View>
  </WinLayout>

  <MDIGroups>
    <Orientation>1</Orientation>
    <ActiveMDIGroup>0</ActiveMDIGroup>
    <MDIGroup>
      <Size>100</Size>
      <ActiveTab>0</ActiveTab>
      <Documents>
        <Doc>
          <Name>.\MAIN.C</Name>
          <ColumnNumber>50</ColumnNumber>
          <TopLine>1</TopLine>
          <CurrentLine>12</CurrentLine>
        </Doc>
        <Doc>
          <Name>D:\temp\Keil\ARM\RV31\INC\string.h</Name>
          <ColumnNumber>63</ColumnNumber>
          <TopLine>110</TopLine>
          <CurrentLine>132</CurrentLine>
        </Doc>
        <Doc>
          <Name>.\LPC2400.s</Name>
          <ColumnNumber>0</ColumnNumber>
          <TopLine>339</TopLine>
          <CurrentLine>347</CurrentLine>
        </Doc>
        <Doc>
          <Name>D:\temp\Keil\ARM\INC\Philips\LPC24xx.H</Name>
          <ColumnNumber>0</ColumnNumber>
          <TopLine>1</TopLine>
          <CurrentLine>1</CurrentLine>
        </Doc>
      </Documents>
    </MDIGroup>
  </MDIGroups>

</ProjectOpt>
